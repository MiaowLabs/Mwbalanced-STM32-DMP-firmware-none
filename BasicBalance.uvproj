# Keil uVision project BasicBalance.uvproj, settings and files
target BasicBalance (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BasicBalance +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\FWlib\inc;.\FWlib\src;.\User;.\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ./FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ./User/: main.c stm32f10x_it.c led.c usart.c I2C_MPU6050.c pwm.c motor.c systick.c upstandingcar.c OUTPUTDATA.c MPU6050.c I2C.c delay.c ADC.c communicate.c dataflash.c common.c
  group Startup
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group DMP
    ./eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
